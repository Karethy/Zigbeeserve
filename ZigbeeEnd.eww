<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CollectTem.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Coordinator.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EndDevice.ewp</path>
  </project>
  <batchBuild/>
</workspace>


